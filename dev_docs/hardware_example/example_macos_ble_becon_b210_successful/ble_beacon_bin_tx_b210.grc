options:
  parameters:
    author: DeepRadio
    category: '[DeepRadio]'
    comment: Transmit the supplied BLE beacon complex-IQ .bin file with a USRP B210 on macOS/RadioConda.
    description: 'The input file is little-endian interleaved float32 I/Q: 200000 complex samples at 2 MS/s. It contains one BLE advertising-channel-38 waveform followed by zero padding to 100 ms, and is repeated continuously.'
    generate_options: no_gui
    id: ble_beacon_bin_tx_b210
    output_language: python
    title: BLE Beacon BIN TX - USRP B210 - Channel 38
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: Must match the .bin waveform sample rate; do not change unless the file is regenerated.
    value: 2e6
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: BLE advertising channel 38 center frequency.
    value: 2426e6
  states: {}
- name: tx_gain
  id: variable
  parameters:
    comment: Original UHD implementation used 65 dB. Reduce for cabled or close-range tests.
    value: '65'
  states: {}
- name: waveform_samples
  id: variable
  parameters:
    comment: 200000 samples / 2 MS/s = 100 ms repeat period.
    value: '200000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: 'Complex64 source: each sample is two native little-endian float32 values (I then Q). Repeat preserves the embedded 100 ms beacon interval.'
    file: /Users/decade/Library/CloudStorage/OneDrive-个人/iiot/5_academia/DeepRadio/experiment/example_macos_ble_becon/ble_beacon_localname_radiomaster.bin
    length: waveform_samples
    repeat: 'True'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: samp_rate
    center_freq0: center_freq
    clock_rate: '0.0'
    clock_source0: internal
    comment: USRP B210 channel A. CPU format fc32 and over-the-wire format sc16 match the previous UHD transmitter.
    dev_addr: '"type=b200"'
    dev_args: '""'
    gain0: tx_gain
    otw: sc16
    samp_rate: samp_rate
    sync: none
    time_source0: internal
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
