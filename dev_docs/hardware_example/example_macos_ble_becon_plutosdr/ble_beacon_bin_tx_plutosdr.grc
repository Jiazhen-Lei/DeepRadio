options:
  parameters:
    author: DeepRadio
    category: '[DeepRadio]'
    comment: Transmit the supplied BLE beacon complex-IQ .bin file with a PlutoSDR on macOS/RadioConda.
    description: 'The input file is little-endian interleaved float32 I/Q: 200000 complex samples at 2 MS/s. It contains one BLE advertising-channel-38 waveform followed by zero padding to 100 ms, and is repeated continuously.'
    generate_options: no_gui
    id: ble_beacon_bin_tx_plutosdr
    output_language: python
    title: BLE Beacon BIN TX - PlutoSDR - Channel 38
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    comment: BLE advertising channel 38 center frequency.
    value: '2426000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Must match the .bin waveform sample rate; do not change unless the file is regenerated.
    value: '2000000'
  states: {}
- name: tx_attenuation
  id: variable
  parameters:
    comment: PlutoSDR TX attenuation in dB. Larger values produce lower RF output power.
    value: '30'
  states: {}
- name: waveform_samples
  id: variable
  parameters:
    comment: 200000 samples / 2 MS/s = 100 ms repeat period.
    value: '200000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: 'Complex64 source: each sample is two native little-endian float32 values (I then Q). Repeat preserves the embedded 100 ms beacon interval.'
    file: ble_beacon_localname_radiomaster.bin
    length: waveform_samples
    repeat: 'True'
    type: complex
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_attenuation
    bandwidth: samp_rate
    buffer_size: '32768'
    comment: PlutoSDR transmitter using the standard USB-network IIO context.
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: center_freq
    len_tag_key: '""'
    samplerate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', iio_pluto_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
