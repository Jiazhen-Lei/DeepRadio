options:
  parameters:
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: qpsk_rx_sim
    output_language: python
  states: {}

blocks:
- name: variable_qpsk
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: analog_random_source
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '100000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_sink
  id: blocks_file_sink
  parameters:
    file: /tmp/qpsk_symbols.bin
    type: complex
  states: {}
- name: channels_channel_model
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.05'
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_decoder
  id: digital_constellation_decoder_cb
  parameters:
    constellation: variable_qpsk
  states: {}
- name: digital_modulator
  id: digital_constellation_modulator
  parameters:
    constellation: variable_qpsk
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: '4'
  states: {}
- name: digital_receiver
  id: digital_constellation_receiver_cb
  parameters:
    constellation: variable_qpsk
    fmax: '0.25'
    fmin: '-0.25'
    loop_bw: 6.28/100.0
  states: {}

connections:
- [analog_random_source, '0', digital_modulator, '0']
- [channels_channel_model, '0', digital_receiver, '0']
- [digital_decoder, '0', blocks_file_sink, '0']
- [digital_modulator, '0', channels_channel_model, '0']
- [digital_receiver, '0', digital_decoder, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
