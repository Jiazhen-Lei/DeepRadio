options:
  parameters:
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: pluto_rx_spectrum_2402M
    output_language: python
  states: {}

blocks:
- name: pluto_src
  id: iio_pluto_source
  parameters:
    bandwidth: '2000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '2402000000'
    gain1: '''manual'''
    manual_gain1: '64'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: '2000000'
    type: fc32
  states: {}
- name: qt_freq
  id: qtgui_freq_sink_x
  parameters:
    bw: '2000000'
    fc: '2402000000'
    fftsize: '1024'
    name: Pluto RX Spectrum 2.402GHz
    type: complex
    update_time: '0.1'
  states: {}
- name: throttle
  id: blocks_throttle
  parameters:
    samples_per_second: '2000000'
    type: complex
  states: {}

connections:
- [pluto_src, '0', qt_freq, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
