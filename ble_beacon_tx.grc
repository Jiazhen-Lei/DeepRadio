options:
  parameters:
    generate_options: no_gui
    generator_class_name: PythonNoGuiGenerator
    generator_module: gnuradio.grc.workflows.python_nogui
    id: ble_beacon_tx
    output_language: python
  states: {}

blocks:
- name: duration_samps
  id: variable
  parameters:
    value: '40000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: '2402000000'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: file_source
  id: blocks_file_source
  parameters:
    file: /session/work/build/ble_beacon_waveform.complex
    repeat: 'True'
    type: complex
  states: {}
- name: head
  id: blocks_head
  parameters:
    num_items: '40000000'
    type: complex
  states: {}
- name: pluto_sink
  id: iio_pluto_sink
  parameters:
    attenuation1: 89 - tx_gain
    bandwidth: '2000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: tx_freq
    samplerate: samp_rate
    type: fc32
  states: {}

connections:
- [file_source, '0', head, '0']
- [head, '0', pluto_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
